# Keil uVision project 万年历.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 万年历 +hex
  c flags: Optimize=8 SizeSpeed=1
  group sourcefiles
    ../source/: LCD1602.c main.c lunar.c DS1302.c DS18B20.c Key_Buzzer.c app.c
  group includefiles
    ../source/: main.h lunar.h LCD1602.h Key_Buzzer.h DS1302.h DS18B20.h config.h app.h
